# Keil uVision project WatchDemo.uvproj, settings and files
target Watch (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: WatchDemo
  c flags: Optim=1
  c include: ..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\Application;..\Hardware\Inc;..\Hardware
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FreeRTOS
    ../FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/MemMang/: heap_2.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Application
    ../Application/: DebugUart.c main.c startup.s LcdTask.c LcdDisplay.c MessageQueues.c LcdBuffer.c BufferPool.c HuffManEngText.c Statistics.c Fonts.c Icons.c IdlePage.c IdlePageMain.c Display.c OneSecondTimers.c CommandTask.c CRC16.c Utilities.c BluetoothSpp.c Background.c FrameBuffer.c Buttons.c IdlePageQrCode.c IdlePageGameOfLife.c
  group Hardware
    ../Hardware/DriverLib/: driverlib.lib
    ../Hardware/: hal_rtc.c hal_battery.c rit128x96x4.c hal_buttons.c hal_timer.c
